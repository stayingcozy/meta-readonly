FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://9p.cfg \
            file://vsock.cfg \
            file://virtio-net.cfg"
